Commit message: Inverse kinematics changed to 3-DOF Arm controller controls the orientation servos

File: src/ik_solver/config/arm5dof.urdf (robot description, URDF)
Before this commit: robot arm5dof, 7 links, 6 joints
Joints:
- joint dof_joint04: type revolute -> fixed
